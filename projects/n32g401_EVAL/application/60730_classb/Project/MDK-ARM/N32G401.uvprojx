# Keil uVision project N32G401.uvprojx, settings and files
target N32G401 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G401C8L7 Nationstech
  pack: Nationstech.N32G401_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G401_SelfTest +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  AfterMake: srecord_crc32.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: N32G401,USE_STDPERIPH_DRIVER,SYSCLK_FREQ=72000000
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc;..\..\..\..\..\..\firmware\CMSIS\device;..\..\Middlewares\N32_SelfTest_Library\inc;..\..\Project
  asm define: ARTISAN=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\N32G401_SelfTest.sct
  group User
    ../: main.c n32g401_it.c CRC32_fast_static_lut.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g401.c
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g401.s
  group N32_SelfTest_Code
    ./: n32g401_STLcpurunKEIL.s n32g401_STLcpustartKEIL.s n32g401_STLRamMcMxKEIL.s
  group N32_SelfTest_Library
    ../../Middlewares/N32_SelfTest_Library/src/: n32g401_STLclockrun.c n32g401_STLclockstart.c n32g401_STLcrc32Run.c n32g401_STLmain.c n32g401_STLstartup.c n32g401_STLtranspRam.c
  group N32G401_Periph
    ../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_crc.c n32g401_dbg.c n32g401_dma.c n32g401_exti.c n32g401_flash.c n32g401_gpio.c n32g401_iwdg.c n32g401_pwr.c n32g401_rcc.c n32g401_rtc.c n32g401_tim.c n32g401_usart.c n32g401_wwdg.c
