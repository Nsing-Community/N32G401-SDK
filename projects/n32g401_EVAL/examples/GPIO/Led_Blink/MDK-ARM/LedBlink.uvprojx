# Keil uVision project LedBlink.uvprojx, settings and files
target N32G401 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G401C8L7 Nationstech
  pack: Nationstech.N32G401_DFP.1.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LedBlink +hex
  AfterMake: fromelf --bin --output=.\bin\LedBlink.bin .\Objects\LedBlink.axf
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G401, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\inc;..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g401.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group FWLB
    ../../../../../../firmware/n32g401_std_periph_driver/src/: n32g401_gpio.c n32g401_rcc.c
  group USER
    ../src/: main.c bsp_led.c n32g401_it.c
  group DELAY
    ../src/: bsp_delay.c
  group DOC
    ../: readme.txt
