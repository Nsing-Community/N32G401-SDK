<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TIM_Dual_Edge_Input_Capture.ewp</path>
    </project>
    <batchBuild />
</workspace>
