# IAR project TIM_Extenal_Trigger_Synchronize.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G401C8 Nations N32G401C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G401; SYSCLK_SRC=SYSCLK_USE_HSE_PLL
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\..\firmware\CMSIS\device\startup; ..\..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc; ..\..\..\TIM_Src; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIM_6_Steps_Commutation.bin
  ILINK.IlinkOutputFile: KTIM_Extenal_Trigger_Synchronizeout
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32G401\N32G401x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group DOC
    ../: readme.txt
  group FWLIB
    ../../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_dbg.c n32g401_dma.c n32g401_gpio.c n32g401_rcc.c n32g401_tim.c
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32g401_EWARM.s
  group TIM_Extenal_Trigger_Synchronize
    ../: main.c
  group TIM_Src
    ../../../TIM_Src/: ADTIM_common.c GPTIM_common.c ISR_common.c timer_common.c
