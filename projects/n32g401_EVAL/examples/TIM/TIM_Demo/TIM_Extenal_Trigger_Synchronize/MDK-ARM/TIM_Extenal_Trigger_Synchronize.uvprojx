# Keil uVision project TIM_Extenal_Trigger_Synchronize.uvprojx, settings and files
target N32G401 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G401C8L7 Nationstech
  pack: Nationstech.N32G401_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIM_Extenal_Trigger_Synchronize
  AfterMake: fromelf --bin --output=.\bin\TIM_Extenal_Trigger_Synchronize.bin .\Objects\TIM_Extenal_Trigger_Synchronize.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,
  c include: ..\;..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc;..\..\..\TIM_Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32g401.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group FWLB
    ../../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_dbg.c n32g401_gpio.c n32g401_rcc.c n32g401_tim.c n32g401_usart.c n32g401_dma.c
  group DOC
    ../: readme.txt
  group TIM_Src
    ../../../TIM_Src/: ADTIM_common.c GPTIM_common.c timer_common.c ISR_common.c
  group TIM_External_Trigger_Synchronize
    ../: main.c
