<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TIM_TIM1_Synchronize.ewp</path>
    </project>
    <batchBuild />
</workspace>
