# Keil uVision project AlarmWakeUp.uvprojx, settings and files
target N32G401 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G401C8L7 Nationstech
  pack: Nationstech.N32G401_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AlarmWakeUp +hex
  AfterMake: fromelf --bin --output=.\bin\AlarmWakeUp.bin .\Objects\AlarmWakeUp.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\AlarmWakeUp.axf --output=.\bin\AlarmWakeUp.dua
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G401, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g401.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group FWLB
    ../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_dma.c n32g401_pwr.c n32g401_rcc.c n32g401_gpio.c n32g401_usart.c n32g401_rtc.c n32g401_exti.c n32g401_flash.c
  group USER
    ../src/: main.c n32g401_it.c delay.c
  group BSP
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
