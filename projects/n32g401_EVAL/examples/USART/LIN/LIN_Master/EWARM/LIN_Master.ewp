# IAR project LIN_Master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G401C8 Nations N32G401C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G401; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\..\firmware\CMSIS\device\startup; ..\..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc; ..\..\..\..\..\bsp\inc; ..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DMA_Polling.bin
  ILINK.IlinkOutputFile: KLIN_Masterout
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32G401\N32G401x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group DOC
    ../: readme.txt
  group FWLIB
    ../../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_gpio.c n32g401_rcc.c n32g401_usart.c
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32g401_EWARM.s
  group USER
    ../src/: delay.c lin_master.c main.c n32g401_it.c
    ../../../../../bsp/src/: log.c
