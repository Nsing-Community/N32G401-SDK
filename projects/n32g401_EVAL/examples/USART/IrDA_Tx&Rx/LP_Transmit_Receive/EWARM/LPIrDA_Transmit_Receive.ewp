# IAR project LPIrDA_Transmit_Receive.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G401C8 Nations N32G401C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G401; USE_STDPERIPH_DRIVER; USE_STDPERIPH_DRIVER; SYSCLK_FREQ=8000000; SYSCLK_SRC=SYSCLK_USE_HSE
  ICCARM.CCDiagSuppress: pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc; ..\..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPIrDA_Transmit_Receive.bin
  ILINK.IlinkOutputFile: LPIrDA_Transmit_Receive.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_gpio.c n32g401_lptim.c n32g401_rcc.c n32g401_tim.c n32g401_usart.c
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32g401_EWARM.s
  group USER
    ../src/: bsp_Tim_38K.c main.c n32g401_it.c
