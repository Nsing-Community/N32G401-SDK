# IAR project LPTIM_WakeUp.ewp, settings and files
configuration N32G401 (ARM, debug)
  General.OGChipSelectEditMenu: N32G401C8 Nations N32G401C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: N32G401; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc; ..\..\..\..\bsp\inc; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\CMSIS\core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32G401\N32G401x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_dbg.c n32g401_exti.c n32g401_gpio.c n32g401_lptim.c n32g401_pwr.c n32g401_rcc.c n32g401_usart.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g401_EWARM.s
  group USER
    ../src/: main.c n32g401_it.c
