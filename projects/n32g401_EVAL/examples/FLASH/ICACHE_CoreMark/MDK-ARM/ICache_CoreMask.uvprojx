# Keil uVision project ICache_CoreMask.uvprojx, settings and files
target N32G401 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G401C8L7 Nationstech
  pack: Nationstech.N32G401_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ICache_CoreMask +hex
  AfterMake: fromelf --bin --output=.\bin\ICache_CoreMask.bin .\Objects\ICache_CoreMask.axf
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G401,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\coremark;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../: startup_n32g401.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group FWLIB
    ../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_flash.c n32g401_gpio.c n32g401_rcc.c n32g401_usart.c
  group USER
    ../src/: main.c n32g401_it.c
  group COREMASK
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group BSP
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
