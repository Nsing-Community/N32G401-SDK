# Keil uVision project RTC_Alarm_Wakup_Standby.uvprojx, settings and files
target N32G401 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G401C8L7 Nationstech
  pack: Nationstech.N32G401_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTC_Alarm_Wakeup_Standby +hex
  AfterMake: fromelf --bin --output=.\bin\RTC_Alarm_Wakeup_Standby.bin .\Objects\RTC_Alarm_Wakeup_Standby.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G401, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc;..\..\..\..\bsp\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g401.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group FWLB
    ../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_exti.c n32g401_gpio.c n32g401_rcc.c n32g401_rtc.c n32g401_usart.c n32g401_pwr.c n32g401_tim.c
  group USER
    ../src/: main.c n32g401_it.c delay.c
  group DOC
    ../: readme.txt
  group LOG
    ../../../../bsp/src/: log.c
