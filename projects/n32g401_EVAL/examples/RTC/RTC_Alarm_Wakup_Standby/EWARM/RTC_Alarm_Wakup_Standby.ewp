# IAR project RTC_Alarm_Wakup_Standby.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G401C8 Nations N32G401C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G401; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g401_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTC_Alarm_Wakup_Standby.bin
  ILINK.IlinkOutputFile: RTC_Alarm.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g401.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g401_std_periph_driver/src/: misc.c n32g401_exti.c n32g401_gpio.c n32g401_pwr.c n32g401_rcc.c n32g401_rtc.c n32g401_tim.c n32g401_usart.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g401_EWARM.s
  group USER
    ../src/: delay.c main.c n32g401_it.c
